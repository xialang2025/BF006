# Keil uVision project BF006.uvproj, settings and files
target STC8H (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: BF006三相380一控一 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src
  group Source
    ./: STARTUP.A51 main.c
    ../src/: delay.c timer.c system.c HT1622.c gpio.c Display.c user.c ad.c EEPROM.c configPar.c key.c RS485.c modbus.c Modbus_New.c RF.c updata4G.c uart4.c
