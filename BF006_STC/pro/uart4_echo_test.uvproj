# Keil uVision project uart4_echo_test.uvproj, settings and files
target UART4 Echo Test (MCS-51)
  device: STC8H3K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0BFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: UART4_Echo_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: UART4_ECHO_TEST
  c include: ..\src
  group Source
    ./: STARTUP.A51
    ../src/: gpio.c uart4.c
    ./tests/: uart4_echo_test.c
